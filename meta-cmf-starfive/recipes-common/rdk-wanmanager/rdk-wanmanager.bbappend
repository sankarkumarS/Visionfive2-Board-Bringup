CFLAGS_remove = "-DINCLUDE_BREAKPAD"

#SRC_URI_append = "breakpad-rdk-wan-mgr-fix.patch"


