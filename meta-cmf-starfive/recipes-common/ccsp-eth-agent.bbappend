CFLAGS_append = " -UINCLUDE_BREAKPAD"

# In the recipe file (e.g., `my-recipe.bb`)
#CFLAGS_append = " -Wno-error=format"

# In the recipe file (e.g., `my-recipe.bb`)
#CFLAGS_append = " -Wno-format"
# In the recipe file (e.g., `my-recipe.bb`)
#CFLAGS_append = " -Wno-error=format"
# In the recipe file (e.g., `my-recipe.bb`)
#CFLAGS_append = " -Wno-error=format"



