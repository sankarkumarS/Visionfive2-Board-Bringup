COMPATIBLE_MACHINE_starfive-visionfive2-rdk-broadband = "starfive-visionfive2-rdk-broadband"
PREFERRED_PROVIDER_virtual/kernel = "linux-starfive-dev"
